# Autodesk Inventor part: DM921_DN300
## iProperties
Created: 2011-03
Part Number: DM921_DN300
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
